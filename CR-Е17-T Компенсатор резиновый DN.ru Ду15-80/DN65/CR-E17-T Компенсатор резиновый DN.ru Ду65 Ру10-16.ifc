Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition []
File name: D:\Работа\Компенсаторы\CR-Е17-T Компенсатор резиновый DN.ru Ду15-80\DN65\CR-E17-T Компенсатор резиновый DN.ru Ду65 Ру10-16.ifc
Time: 2026-02-18T12:19:32
Written by: IFCConverter v1.0
Made in: KOMPAS-3D 24.0.2903

# IfcProject, Default project
Phase: MODIFIED

# IfcBuildingElementProxy, Твердое тело1
In: Default building
System - Масса: 5.04771 kg; Наименование: Твердое тело1; Раздел спецификации: Прочие изделия; Класс точности: c; Комментарий: D140-02404; Рассекать на разрезах: 752; Примечание: D140-02404; Знак неуказанной шероховатости: 0
IfcPropertySet - __ComponentName: Компенсатор резиновый DN.ru Ду65 Ру10/16; __ComponentColor: #909090; __BodyName: Твердое тело1; __BodyColor: #BFBFBF; Типовые: Типовые
