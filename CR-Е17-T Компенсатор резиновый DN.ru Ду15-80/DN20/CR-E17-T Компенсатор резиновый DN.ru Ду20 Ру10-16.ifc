Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition []
File name: D:\PROJECT CAD\DN.RU\...188. Компенсатор резиновый DN.ru CR-x17-T Ду15-80\188. Компенсатор резиновый DN.ru CR-x17-T Ду15-80\DN20\Компенсатор резиновый DN.ru CR-x17-T Ду20 Ру10-16.ifc
Time: 2026-02-16T18:53:03
Written by: IFCConverter v1.0
Made in: KOMPAS-3D 24.0.2799

# IfcProject, Default project
Phase: MODIFIED

# IfcBuildingElementProxy, Твердое тело1
In: Default building
System - Масса: 1.99583 kg; Наименование: Твердое тело1; Раздел спецификации: Прочие изделия; Класс точности: c; Комментарий: D140-02210; Рассекать на разрезах: 752; Знак неуказанной шероховатости: 0
IfcPropertySet - __ComponentName: Компенсатор резиновый DN.ru CR-x17-T Ду20 Ру10-16; __ComponentColor: #909090; __BodyName: Твердое тело1; __BodyColor: #BFBFBF; Типовые: Типовые
